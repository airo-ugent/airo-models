Commit message: zed2i camera: orient correctly and put origin at left eye

File: airo_models/cameras/zed2i/zed2i.urdf (robot description, URDF)
Before this commit: robot zed2i, 3 links, 2 joints
Joints:
- joint pose_of_right_eye_in_left_eye: origin xyz=-0.12 0 0 rpy=0 0 0 -> xyz=0.12 0 0 rpy=0 0 0
